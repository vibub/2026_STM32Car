# IAR project STM32Car.ewp, settings and files
configuration STM32H745I_Nucleo_CM7 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H745ZI_CM7 ST STM32H745ZI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H745xx; CORE_CM7
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM7\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\App\Inc; ..\Bsp\Inc; ..\Control\Inc; ..\Protocol\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32Car_CM7.hex
  ILINK.IlinkOutputFile: STM32Car_CM7.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c
  group Example/EWARM
    ./: startup_stm32h745xx.s
  group Example/User/CM7
    ../CM7/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Example/User/App
    ../App/Src/: app_main.c
  group Example/User/Bsp
    ../Bsp/Src/: board_time.c encoder_driver.c infrared_line_sensor.c imu_heading.c k230_uart.c tjc_uart.c motor_driver.c servo_driver.c oled_display.c
  group Example/User/Control
    ../Control/Src/: infrared_line_control.c wheel_speed_pid.c lap_stop_detector.c
  group Example/User/Protocol
    ../Protocol/Src/: protocol_tjc.c
